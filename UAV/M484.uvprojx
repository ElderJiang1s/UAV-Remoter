# Keil uVision project M484.uvprojx, settings and files
target Target 1 (6120000::V6.12::.\ARMCLANG)
  device: M484SIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.3
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: M484 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4=1, __FPU_PRESENT=1UL,MPL_LOG_NDEBUG=1,EMPL,MPU9250,EMPL_TARGET_STM32F4,nVCOM_PRINTF
  c include: .\CORE;.\LIBRARY\inc;.\USER;.\SYSTEM\delay;.\SYSTEM\usart;.\SYSTEM\MALLOC;.\SYSTEM\i2c;.\SYSTEM\spi;.\SYSTEM\lcd;.\SYSTEM\sdcard;.\SYSTEM\sdcard\FatFs\src;.\SYSTEM\dsp;.\SYSTEM\HSUSBD\UAC;.\SYSTEM\report;.\SYSTEM\DMP\driver\eMPL;.\SYSTEM\DMP\driver\include;.\SYSTEM\DMP\driver\stm32L;.\SYSTEM\DMP\eMPL-hal;.\SYSTEM\DMP\mllite;.\SYSTEM\DMP\mpl;.\SYSTEM\HSUSBD;.\SYSTEM\AHRS;.\SYSTEM\APP;.\FreeRTOS\include;.\FreeRTOS\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  group USER
    ./USER/: main.c cm4.c uav_s.c
  group CORE
    ./CORE/: startup_M480.s system_M480.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/MALLOC/: malloc.c
    ./SYSTEM/report/: report.c
  group LIBRARY
    ./LIBRARY/src/: clk.c gpio.c acmp.c bpwm.c can.c crc.c crypto.c dac.c eadc.c ebi.c ecap.c emac.c epwm.c fmc.c hsusbd.c i2c.c i2s.c pdma.c qei.c qspi.c retarget.c rtc.c sc.c scuart.c sdh.c spi.c spim.c sys.c timer.c timer_pwm.c uart.c usbd.c usci_i2c.c usci_spi.c usci_uart.c wdt.c wwdt.c
  group I2C
    ./SYSTEM/i2c/: bmpxxx.c eeprom.c fram.c OLED_I2C.c MyI2C.c mpu6050.c
  group SPI
    ./SYSTEM/spi/: 24l01.c
  group DSP
    ./SYSTEM/dsp/: arm_cortexM4lf_math.lib
  group AHRS
    ./SYSTEM/AHRS/: AHRSLibM4.lib
  group APP
    ./SYSTEM/APP/: Filter.c IMU.c pid.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ./FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
